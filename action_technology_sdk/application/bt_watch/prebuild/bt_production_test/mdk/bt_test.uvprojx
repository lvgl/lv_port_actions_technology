# Keil uVision project bt_test.uvprojx, settings and files
target bt_test (6140000::V6.14::ARMCLANG)
  device: STAR_CU ArmChina
  pack: ArmChina.STAR.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: bt_test +hex (library)
  AfterMake: .\bt_test.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\inc
  asm include: ..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group bttest
    ../: fcc_test_main.c
