# Keil uVision project template.uvprojx, settings and files
target zephyr (6160000::V6.16::ARMCLANG)
  device: STAR_CU ArmChina
  pack: ArmChina.STAR.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: zephyr
  AfterMake: UserCommand.bat "!L" "$K\ARM"
  AfterMake: PackCommand.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -mcpu=cortex-m33+nodsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
