# Keil uVision project cfg_make.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: cfg_make (library)
  BeforeMake: prepare.bat
  AfterMake: post.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\framework\system\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./out/: config.dat.c config.xml.c
